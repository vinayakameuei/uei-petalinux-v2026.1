# Copyright (C) 2025 UEI Inc.

DESCRIPTION = "UEI SDK Image Zynqmp"
LICENSE = "MIT"

require uei-image-common-zynq.inc
require uei-image-base-zynq.inc

IMAGE_NAME_SUFFIX ?= ""
