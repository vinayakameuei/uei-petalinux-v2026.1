#PACKAGECONFIG += " fapi"

#RM_WORK_EXCLUDE += "${PN}"
