# This tells bitbake where to find the files we're providing on the local filesystem
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
OPTEEMACHINE:ueipdnasx6-rt = "imx-mx6sxsabresd"
PLATFORM_FLAVOR:ueipdnasx6-rt = "mx6sxsabresd"
