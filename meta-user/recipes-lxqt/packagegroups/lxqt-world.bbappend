RDEPENDS:${PN}:remove = "lxqt-powermanagement pavucontrol-qt"
