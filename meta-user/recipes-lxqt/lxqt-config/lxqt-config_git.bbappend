DEPENDS += "libxi"
