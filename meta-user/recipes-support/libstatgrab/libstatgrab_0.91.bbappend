SRC_URI = "https://ftp.i-scream.org/pub/i-scream/${PN}/${PN}-${PV}.tar.gz"
