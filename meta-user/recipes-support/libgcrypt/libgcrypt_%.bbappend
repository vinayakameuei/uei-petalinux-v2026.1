#AT added
EXTRA_OECONF:append_mingw32 = " --disable-amd64-as-feature-detection"
